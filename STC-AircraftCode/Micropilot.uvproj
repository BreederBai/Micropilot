# Keil uVision project Micropilot.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Micropilot +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 EEPROM.C IMU.C Micropilot.C MPU-6050.C NRF24L01.C STC15W4KPWM.C Timer.C USART.C
